# Keil uVision project FromScratch.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FromScratch
  AfterMake: xcopy "Objects\*.axf" "*.elf" /Y
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c include: MCAL/;HAL/
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: main.c
  group MCAL
    ./MCAL/: stm32f103c8.h MY_STM32_GPIO.c MY_STM32_GPIO.h MY_STM32_RCC.c MY_STM32_RCC.h MY_STM32_EXTI.c MY_STM32_EXTI.h MY_STM32_USART.c MY_STM32_USART.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
