# Keil uVision project I2C_Controller.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI_Controller +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c include: MCAL/;HAL/
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group Includes
    ./HAL/LCD_DRIVER/: lcd.c lcd.h
    ./HAL/KEYPAD_DRIVER/: keypad.c keypad.h
    ./MCAL/: stm32f103x6.h
    ./MCAL/EXTI_Driver/: Stm32_F103C6_EXTI_Driver.c Stm32_F103C6_EXTI_Driver.h
    ./MCAL/GPIO_Drivers/: Stm32_F103C6_gpio_driver.c Stm32_F103C6_gpio_driver.h
    ./MCAL/RCC_Drivers/: Stm32_F103C6_RCC_driver.c Stm32_F103C6_RCC_driver.h
    ./MCAL/USART_Driver/: Stm32_F103C6_USART_driver.c Stm32_F103C6_USART_driver.h
    ./MCAL/SPI_Drivers/: Stm32_F103C6_SPI_driver.c Stm32_F103C6_SPI_driver.h
    ./MCAL/I2C_Drivers/: Stm32_F103C6_I2C_driver.c Stm32_F103C6_I2C_driver.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
