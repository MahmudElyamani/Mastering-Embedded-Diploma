# Keil uVision project Drivers.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Drivers +hex
  AfterMake: xcopy "Objects\*.axf" "*.elf" /Y
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\HAL;.\MCAL
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: main.c
  group GPIO_Drivers
    ./MCAL/GPIO_Drivers/: Stm32_F103C6_gpio_driver.c Stm32_F103C6_gpio_driver.h
  group LCD_Drivers
    ./HAL/LCD_DRIVER/: lcd.c lcd.h
  group Keypad_Drivers
    ./HAL/KEYPAD_DRIVER/: keypad.c keypad.h
  group Stm32_F103C6_Drivers
    ./MCAL/: stm32f103x6.h
  group EXTI_Driver
    ./MCAL/EXTI_Driver/: Stm32_F103C6_EXTI_Driver.c Stm32_F103C6_EXTI_Driver.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
